# Repository mkomakonkon/MZ-2000

File README.md:

# MZ-2000　　

★このページのデータをDLしてエミュで再生するだけの動画を投稿する人は、自分でプログラムを組む勉強くらいした方がいいと思います。 

[wiki作ってみました](https://github.com/mkomakonkon/MZ-2000/wiki)  

■DIGITAL_INVADER_for2000
　MZ-80K/Cからの移植  
 
■IO I/Oを打ち込んだ物

■MZ-80B MZ-80B関連

■OMEGA_CG
　ブリジットちゃん描いてみた

■Oh!MZ
　Oh!MZを打ち込んだ物
 
■TIME_LIMIT2
　昔作ったゲームをマシン語化でちょっと機能追加
 
■image
  キャプチャなどの画像置き場(公開用ではないです)  

■misc
  なんか作ってみた

■tmp
　未完成のもの
 
■ミランダでSPACE連射
　ミランダをいろいろ改造してみた

ごちゃごちゃしてきたのでフォルダ構成見直そうかな？  
あと、Markdownで動画を埋め込む方法が分かったので限定公開動画をいろいろうｐするかも…

## KiCad design misc/CMU-800/VOCALUINO4CMU/MZ-2000_VOCALUINO4CMU/MZ-2000_VOCALUINO4CMU.kicad_pcb

Parts:
A1: Arduino_Nano
A2: Arduino_Nano_RP2040_Connect; Arduino_Nano
C1: 100uF; CP_Radial_D5.0mm_P2.50mm
C2, C4, C6, C8, C9, C11: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3, C7, C12, C14, C16: 0.022u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C5, C10, C13, C15: 0.047u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1: 1N4148WT; D_T-1_P5.08mm_Horizontal
IC6: 8255; DIP-40_W15.24mm
IC9: 74LS139; DIP-16_W7.62mm
IC10: 74LS138; DIP-16_W7.62mm
J1: Conn_02x22_Row_Letter_First; BUS_MZ2000
J2: Conn_02x22_Row_Letter_First; PinHeader_2x22_P2.54mm_Vertical
J3, J4, J5: Conn_01x02_Pin; 5V-GND-TH
R1, R3, R10, R13, R22: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2, R4, R11, R14: 5.1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R6, R15, R16: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7, R8, R9, R12: 0; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R17, R18, R19, R20: 220; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R21: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R23: 3.3K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RA1: 10K; R_Array_SIP9
U1: 74LS259; DIP-16_W7.62mm_Socket
U2, U3, U4, U5: ATP3011-PU; CERDIP-28_W7.62mm_SideBrazed
V1, V2, V3, V4: LED; LED_D3.0mm_Clear
VOUT1: AudioJack3; Jack_3.5mm_Switronic_ST-005-G_horizontal

Connections:
*ATP_RST1: A1.16 (D13/SCK), U2.1 (~RESET), U3.1 (~RESET)
*ATP_RST2: A2.16 (D13/SCK), U4.1 (~RESET), U5.1 (~RESET)
+5V: A1.30 (VIN), A2.30 (VIN), C1.1, C2.2, C4.2, C6.1, C8.1, C9.2, C11.2, C16.1, IC6.26 (VCC), IC9.16 (VCC), IC10.6 (E3), IC10.16 (VCC), J1.a1, J1.b1, J2.a1, J2.b1, J3.1, J4.1, J5.1, R5.2, R6.2, R15.2, R16.2, R22.2, R23.2, RA1.1 (common), U1.16 (VCC), U2.7 (Vcc), U2.20 (Vcc), U3.7 (Vcc), U3.20 (Vcc), U4.7 (Vcc), U4.20 (Vcc), U5.7 (Vcc), U5.20 (Vcc), V1.2 (A), V2.2 (A), V3.2 (A), V4.2 (A)
/A0: IC6.9 (A0), J1.a21, J2.a21
/A1: IC6.8 (A1), J1.a20, J2.a20
/A2: IC9.3 (A1), J1.a19, J2.a19
/A3: IC9.2 (A0), J1.a18, J2.a18
/A4: IC9.14 (A0), J1.a17, J2.a17
/A5: IC10.3 (A2), J1.a16, J2.a16
/A6: IC10.2 (A1), J1.a15, J2.a15
/A7: IC10.1 (A0), J1.a14, J2.a14
/A8: J1.a13, J2.a13
/A9: J1.a12, J2.a12
/A10: J1.a11, J2.a11
/A11: J1.a10, J2.a10
/A12: J1.a9, J2.a9
/A13: J1.a8, J2.a8
/A14: J1.a7, J2.a7
/A15: J1.a6, J2.a6
/CMU-SEL0: IC9.13 (A1), IC9.15 (E), IC10.14 (O1)
/CMU-SEL1: IC9.1 (E), IC9.11 (O1)
/D0: IC6.34 (D0), J1.a4, J2.a4, RA1.9 (R8)
/D1: IC6.33 (D1), J1.a3, J2.a3, RA1.8 (R7)
/D2: IC6.32 (D2), J1.a2, J2.a2, RA1.7 (R6)
/D3: IC6.31 (D3), J1.b2, J2.b2, RA1.6 (R5)
/D4: IC6.30 (D4), J1.b3, J2.b3, RA1.5 (R4)
/D5: IC6.29 (D5), J1.b4, J2.b4, RA1.4 (R3)
/D6: IC6.28 (D6), J1.b5, J2.b5, RA1.3 (R2)
/D7: IC6.27 (D7), J1.b6, J2.b6, RA1.2 (R1)
/IE0: J1.b16, J2.b16
/IE1: J1.b15, J2.b15
/RST: J1.b17, J2.b17
/SEL8253-0: IC9.4 (O0)
/SEL8253-1: IC9.6 (O2)
/SEL8255: IC6.6 (~CS), IC9.5 (O1)
/phi: J1.b7, J2.b7
/~EXINT: J1.b19, J2.b19
/~EXRESET: J1.b18, J2.b18
/~EXWAIT: J1.b20, J2.b20
/~HALT: J1.b14, J2.b14
/~IOREQ: IC10.4 (E1), J1.b11, J2.b11
/~M1: J1.b8, J2.b8
/~MNI: J1.b21, J2.b21
/~MREQ: J1.b12, J2.b12
/~RD: J1.b10, J2.b10
/~WR: IC6.36 (~WR), J1.b9, J2.b9
ATP-OUT: C5.2, C10.2, C13.2, C15.2, VOUT1.R, VOUT1.T
BD: IC6.25 (PB7)
CH: IC6.19 (PB1)
CHA: A1.19 (A0), A2.19 (A0), IC6.15 (PC1), U1.1 (A0)
CHB: A1.20 (A1), A2.20 (A1), IC6.16 (PC2), U1.2 (A1)
CHC: A1.21 (A2), A2.21 (A2), IC6.17 (PC3), U1.3 (A2)
CHD: A1.22 (A3), A2.22 (A3), IC6.14 (PC0), U1.14 (E)
CY: IC6.21 (PB3)
GATE1: U1.4 (Q0)
GATE2: U1.5 (Q1)
GATE3: U1.6 (Q2)
GATE4: U1.7 (Q3)
GATE5: U1.9 (Q4)
GATE6: U1.10 (Q5)
GATE7: U1.11 (Q6)
GATE8: U1.12 (Q7)
GATE_DATA: A1.11 (D8), A2.11 (D8), IC6.37 (PA7), U1.13 (D)
GND: A1.4 (GND), A1.29 (GND), A2.4 (GND), A2.29 (GND), C1.2, C2.1, C3.2, C4.1, C6.2, C7.2, C8.2, C9.1, C11.1, C12.2, C14.2, D1.2 (A), IC6.7 (GND), IC9.8 (GND), IC10.5 (E2), IC10.8 (GND), J1.a5, J1.a22, J1.b13, J1.b22, J2.a5, J2.a22, J2.b13, J2.b22, J3.2, J4.2, J5.2, R2.1, R4.1, R7.1, R8.1, R9.1, R11.1, R12.1, R14.1, R21.1, U1.8 (GND), U2.8 (GND), U2.22 (GND), U3.8 (GND), U3.22 (GND), U4.8 (GND), U4.22 (GND), U5.8 (GND), U5.22 (GND), VOUT1.S
HT: IC6.22 (PB4)
LT: IC6.23 (PB5)
N_RESET: A1.3 (~RESET), A2.3 (~RESET)
unnamed: C3.1, C5.1, R1.2, R2.2
unnamed: C7.1, C10.1, R3.2, R4.2
unnamed: C12.1, C13.1, R10.2, R11.2
unnamed: C14.1, C15.1, R13.2, R14.2
unnamed: IC6.5 (~RD), R22.1
unnamed: R23.1, U1.15 (Clr)
unnamed: R1.1, U2.12 (AOUT)
unnamed: R7.2, U2.4 (SMOD0)
unnamed: R19.1, U2.13 (~PLAY)
unnamed: R3.1, U3.12 (AOUT)
unnamed: R8.2, U3.4 (SMOD0)
unnamed: R20.1, U3.13 (~PLAY)
unnamed: R10.1, U4.12 (AOUT)
unnamed: R9.2, U4.4 (SMOD0)
unnamed: R17.1, U4.13 (~PLAY)
unnamed: R13.1, U5.12 (AOUT)
unnamed: R12.2, U5.4 (SMOD0)
unnamed: R18.1, U5.13 (~PLAY)
unnamed: R19.2, V1.1 (K)
unnamed: R20.2, V2.1 (K)
unnamed: R17.2, V3.1 (K)
unnamed: R18.2, V4.1 (K)
OH: IC6.20 (PB2)
RESET: C16.2, D1.1 (K), IC6.35 (RESET), R21.2
SCL_CH1: A1.24 (SCL/A5), R6.1, U2.28 (SCL), U3.28 (SCL)
SCL_CH2: A2.24 (SCL/A5), R16.1, U4.28 (SCL), U5.28 (SCL)
SD: IC6.24 (PB6)
SDA_CH1: A1.23 (SDA/A4), R5.1, U2.27 (SDA), U3.27 (SDA)
SDA_CH2: A2.23 (SDA/A4), R15.1, U4.27 (SDA), U5.27 (SDA)
VD0: A1.5 (D2), A2.5 (D2), IC6.4 (PA0)
VD1: A1.6 (D3), A2.6 (D3), IC6.3 (PA1)
VD2: A1.7 (D4), A2.7 (D4), IC6.2 (PA2)
VD3: A1.8 (D5), A2.8 (D5), IC6.1 (PA3)
VD4: A1.9 (D6), A2.9 (D6), IC6.40 (PA4)
VD5: A1.10 (D7), A2.10 (D7), IC6.39 (PA5)

Notes on the sheet:
LS259はArduinoに取り込んだのでreserve
260919:Arduinoのリセットは負論理なので8255と分離。現時点では切り離しただけ
260923:Arduino⇔ATP間I2Cの接続ミス修正
260920:8255のポートアサインミス（0-7→7-0）
260918:8255のRDを5V固定にして殺す。

Board: 2 copper layers, 138.2 x 142.7 mm, 65 parts (0 on the bottom side), 85 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm_M3

File misc/CMU-800/VOCALUINO4CMU/MZ-2000_VOCALUINO4CMU/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_446, _445, _444, _443, _442, _441, _440, _439, _438, _437, _436, _435, _434, _433, _432, _431, _430, _429, _428, _427, _426, _425, _424, _423, _422, _421, _420, _419, _418, _417, _416, _415, _414, _413, _412, _411, _410, _409, _408, _407, _406, _405, _404, _403, _402, _401, _400, _399, _398, _397, _396, _395, _394, _393, _392, _391, _390, _389, _388, _387, _386, _385, _384, _383, _382, _381, _380, _379, _378, _377, _376, _375, _374, _373, _372, _371, _370, _369, _368, _367, _366, _365, _364, _363, _362, _361, _360, _359, _358, _357, _356, _355, _354, _353, _352, _351, _350, _349, _348, _347, _346, _345, _344, _343, _342, _341, _340, _339, _338, _337, _336, _335, _334, _333, _332, _331, _330, _329, _328, _327, _326, _325, _324, _323, _322, _321, _320, _319, _318, _317, _316, _315, _314, _313, _312, _311, _310, _309, _308, _307, _306, _305, _304, _303, _302, _301, _300, _299, _298, _297, _296, _295, _294, _293, _292, _291, _290, _289, _288, _287, _286, _285, _284, _283, _282, _281, _280, _279, _278, _277, _276, _275, _274, _273, _272, _271, _270, _269, _268, _267, _266, _265, _264, _263, _262, _261, _260, _259, _258, _257, _256, _255, _254, _253, _252, _251, _250, _249, _248, _247",,200,,
"_246, _245, _244, _243, _242, _241, _240, _239, _238, _237, _236, _235, _234, _233, _232, _231, _230, _229, _228, _227, _226, _225, _224, _223, _222, _221, _220, _219, _218, _217, _216, _215, _214, _213, _212, _211, _210, _209, _208, _207, _206, _205, _204, _203, _202, _201, _200, _199, _198, _197, _196, _195, _194, _193, _192, _191, _190, _189, _188, _187, _186, _185, _184, _183, _182, _181, _180, _179, _178, _177, _176, _175, _174, _173, _172, _171, _170, _169, _168, _167, _166, _165, _164, _163, _162, _161, _160, _159, _158, _157, _156, _155, _154, _153, _152, _151, _150, _149, _148, _147, _146, _145, _144, _143, _142, _141, _140, _139, _138, _137, _136, _135, _134, _133, _132, _131, _130, _129, _128, _127, _126, _125, _124, _123, _122, _121, _120, _119, _118, _117, _116, _115, _114, _113, _112, _111, _110, _109, _108, _107, _106, _105, _104, _103, _102, _101, _100, _99, _98, _97, _96, _95, _94, _93, _92, _91, _90, _89, _88, _87, _86, _85, _84, _83, _82, _81, _80, _79, _78, _77, _76, _75, _74, _73, _72, _71, _70, _69, _68, _67, _66, _65, _64, _63, _62, _61, _60, _59, _58, _57, _56, _55, _54, _53, _52, _51, _50, _49, _48, _47",,200,,
"_46, _45, _44, _43, _42, _41, _40, _39, _38, _37, _36, _35, _34, _33, _32, _31, _30, _29, _28, _27, _26, _25, _24, _23, _22, _21, _20, _19, _18, _17, _16, _15, _14, _13, _12, _11, _10, _9, _8, _7, _6, _5, _4, _3, _2, ",,46,,
A1,Arduino_Nano,1,Arduino_Nano,
A2,Arduino_Nano,1,Arduino_Nano_RP2040_Connect,
C1,CP_Radial_D5.0mm_P2.50mm,1,100uF,
"C10, C13, C15, C5",C_Disc_D4.3mm_W1.9mm_P5.00mm,4,0.047u,
"C11, C2, C4, C6, C8, C9",C_Disc_D4.3mm_W1.9mm_P5.00mm,6,0.1u,
"C12, C14, C16, C3, C7",C_Disc_D4.3mm_W1.9mm_P5.00mm,5,0.022u,
D1,D_T-1_P5.08mm_Horizontal,1,1N4148WT,
IC10,DIP-16_W7.62mm,1,74LS138,
IC6,DIP-40_W15.24mm,1,8255,
IC9,DIP-16_W7.62mm,1,74LS139,
J1,BUS_MZ2000,1,Conn_02x22_Row_Letter_First,
J2,PinHeader_2x22_P2.54mm_Vertical,1,Conn_02x22_Row_Letter_First,
"J3, J4, J5",5V-GND-TH,3,Conn_01x02_Pin,
"R1, R10, R13, R22, R3",R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,5,10K,
"R11, R14, R2, R4",R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,4,5.1K,
"R12, R7, R8, R9",R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,4,0,
"R15, R16, R5, R6",R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,4,1K,
"R17, R18, R19, R20",R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,4,220,
R21,R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,1,1M,
R23,R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal,1,3.3K,
RA1,R_Array_SIP9,1,10K,
U1,DIP-16_W7.62mm_Socket,1,74LS259,
"U2, U3, U4, U5",CERDIP-28_W7.62mm_SideBrazed,4,ATP3011-PU,
"V1, V2, V3, V4",LED_D3.0mm_Clear,4,LED,
VOUT1,Jack_3.5mm_Switronic_ST-005-G_horizontal,1,AudioJack3,

## KiCad design PCB/MZ-2000_DEBUG/MZ-2000_DEBUG.kicad_pcb

File PCB/MZ-2000_DEBUG/README.md:

20260322:シルクとピンアサインを修正済。  
タイミングが厳しいカードは動かないかもしれません。

Parts:
F1: RHT050; Fuse_Bourns_MF-RHT050
J1: Conn_02x22_Row_Letter_First; BUS_MZ2000
J2, J3: Conn_02x22_Row_Letter_First; PinHeader_2x22_P2.54mm_Vertical
J4: Conn_02x25_Odd_Even; BUS_50Pin
J5, J6, J7, J8: Conn_02x22_Row_Letter_First; Cardedge-conn_2x22_P2.54mm
J9, J10, J11, J12, J13, J14, J15, J16: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical

Connections:
+5V: F1.2, J3.a1, J3.b1, J4.49, J4.50, J5.a1, J5.b1, J6.a1, J6.b1, J7.a1, J7.b1, J8.a1, J8.b1
/A0: J1.a21, J2.a21, J3.a21, J4.9, J5.b21, J6.b21, J7.b21, J8.b21
/A1: J1.a20, J2.a20, J3.a20, J4.11, J5.b20, J6.b20, J7.b20, J8.b20
/A2: J1.a19, J2.a19, J3.a19, J4.13, J5.b19, J6.b19, J7.b19, J8.b19
/A3: J1.a18, J2.a18, J3.a18, J4.15, J5.b18, J6.b18, J7.b18, J8.b18
/A4: J1.a17, J2.a17, J3.a17, J4.17, J5.b17, J6.b17, J7.b17, J8.b17
/A5: J1.a16, J2.a16, J3.a16, J4.19, J5.b16, J6.b16, J7.b16, J8.b16
/A6: J1.a15, J2.a15, J3.a15, J4.21, J5.b15, J6.b15, J7.b15, J8.b15
/A7: J1.a14, J2.a14, J3.a14, J4.23, J5.b14, J6.b14, J7.b14, J8.b14
/A8: J1.a13, J2.a13, J3.a13, J4.25, J5.b13, J6.b13, J7.b13, J8.b13
/A9: J1.a12, J2.a12, J3.a12, J4.27, J5.b12, J6.b12, J7.b12, J8.b12
/A10: J1.a11, J2.a11, J3.a11, J4.29, J5.b11, J6.b11, J7.b11, J8.b11
/A11: J1.a10, J2.a10, J3.a10, J4.31, J5.b10, J6.b10, J7.b10, J8.b10
/A12: J1.a9, J2.a9, J3.a9, J4.33, J5.b9, J6.b9, J7.b9, J8.b9
/A13: J1.a8, J2.a8, J3.a8, J4.35, J5.b8, J6.b8, J7.b8, J8.b8
/A14: J1.a7, J2.a7, J3.a7, J4.37, J5.b7, J6.b7, J7.b7, J8.b7
/A15: J1.a6, J2.a6, J3.a6, J4.39, J5.b6, J6.b6, J7.b6, J8.b6
/D0: J1.a4, J2.a4, J3.a4, J4.43, J5.b4, J6.b4, J7.b4, J8.b4
/D1: J1.a3, J2.a3, J3.a3, J4.45, J5.b3, J6.b3, J7.b3, J8.b3
/D2: J1.a2, J2.a2, J3.a2, J4.47, J5.b2, J6.b2, J7.b2, J8.b2
/D3: J1.b2, J2.b2, J3.b2, J4.48, J5.a2, J6.a2, J7.a2, J8.a2
/D4: J1.b3, J2.b3, J3.b3, J4.46, J5.a3, J6.a3, J7.a3, J8.a3
/D5: J1.b4, J2.b4, J3.b4, J4.44, J5.a4, J6.a4, J7.a4, J8.a4
/D6: J1.b5, J2.b5, J3.b5, J4.42, J5.a5, J6.a5, J7.a5, J8.a5
/D7: J1.b6, J2.b6, J3.b6, J4.40, J5.a6, J6.a6, J7.a6, J8.a6
/IE0: J1.b16, J2.b16, J3.b16, J4.20, J5.a16, J6.a16, J7.a16, J8.a16
/IE1: J1.b15, J2.b15, J3.b15, J4.22, J5.a15, J6.a15, J7.a15, J8.a15
/RESET: J1.b17, J2.b17, J3.b17, J4.18, J5.a17, J6.a17, J7.a17, J8.a17
/phi: J1.b7, J2.b7, J3.b7, J4.38, J5.a7, J6.a7, J7.a7, J8.a7
/~EXINT: J1.b19, J2.b19, J3.b19, J4.14, J5.a19, J6.a19, J7.a19, J8.a19
/~EXRESET: J1.b18, J2.b18, J3.b18, J4.16, J5.a18, J6.a18, J7.a18, J8.a18
/~EXWAIT: J1.b20, J2.b20, J3.b20, J4.12, J5.a20, J6.a20, J7.a20, J8.a20
/~HALT: J1.b14, J2.b14, J3.b14, J4.24, J5.a14, J6.a14, J7.a14, J8.a14
/~IOREQ: J1.b11, J2.b11, J3.b11, J4.30, J5.a11, J6.a11, J7.a11, J8.a11
/~M1: J1.b8, J2.b8, J3.b8, J4.36, J5.a8, J6.a8, J7.a8, J8.a8
/~MNI: J1.b21, J2.b21, J3.b21, J4.10, J5.a21, J6.a21, J7.a21, J8.a21
/~MREQ: J1.b12, J2.b12, J3.b12, J4.28, J5.a12, J6.a12, J7.a12, J8.a12
/~RD: J1.b10, J2.b10, J3.b10, J4.32, J5.a10, J6.a10, J7.a10, J8.a10
/~WR: J1.b9, J2.b9, J3.b9, J4.34, J5.a9, J6.a9, J7.a9, J8.a9
GND: J1.a22, J1.b22, J2.a22, J2.b22, J3.a22, J3.b22, J4.7, J4.8, J5.a22, J5.b22, J6.a22, J6.b22, J7.a22, J7.b22, J8.a22, J8.b22, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1
GND1: J1.a5, J2.a5, J3.a5, J4.41, J5.b5, J6.b5, J7.b5, J8.b5
GND2: J1.b13, J2.b13, J3.b13, J4.26, J5.a13, J6.a13, J7.a13, J8.a13
VCC: F1.1, J1.a1, J1.b1, J2.a1, J2.b1

Board: 2 copper layers, 115.8 x 158.4 mm, 29 parts (13 on the bottom side), 43 nets.

Other parts of the board:
MH1, MH1#2, MH1#3, MH1#4, MH1#5, MH1#6, MH1#7, MH1#8, MH1#9, MH2, MH3, MH4: MountingHole_3.2mm_M3

File PCB/MZ-2000_DEBUG/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"_3, _2, ",,3,,
F1,Fuse_Bourns_MF-RHT050,1,RHT050,
J1,BUS_MZ2000,1,Conn_02x22_Row_Letter_First,
"J10, J11, J12, J13, J14, J15, J16, J9",PinHeader_1x01_P2.54mm_Vertical,8,Conn_01x01_Pin,
"J2, J3",PinHeader_2x22_P2.54mm_Vertical,2,Conn_02x22_Row_Letter_First,
J4,BUS_50Pin,1,Conn_02x25_Odd_Even,
"J5, J6, J7, J8",Cardedge-conn_2x22_P2.54mm,4,Conn_02x22_Row_Letter_First,

## Code that names these connections

File PCB/MZ-2000_VOCALUINO4CMU/DEMO2/A1_CLOCK_UNIT_VOICE_EXINT2.ino (part):

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volatile bool exintPhase = false;
volatile bool exintEnabled = false;   // 起動時はOFF。シリアルから E1 でON、E0でOFF
volatile bool resetSeen = false;      // MZのリセットを検出した(メッセージ表示用)
#define MZRESET_BIT        PB4        // D12 <- MZのRESET(正論理: リセット中=HIGH)。/EXRESETは使わない

const int PIN_S0   = A0;   // CHA
const int PIN_S1   = A1;   // CHB
const int PIN_S2   = A2;   // CHC
const int PIN_G    = A3;   // CHD = /G
const int PIN_D    = 8;    // GATE = D
const int PIN_ATP_RST = 13; // *ATP_RST

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
// ---- EXINT パルス (Timer1 比較割り込み) ----
ISR(TIMER1_COMPA_vect) {            // OC1Aのトグルと同時(半周期ごと)
  if (PINB & _BV(MZRESET_BIT)) {             // MZがリセット中: EXINTを止めて、OFFに戻す
    if (exintEnabled) resetSeen = true;
    exintEnabled = false;
    DDRB &= ~_BV(EXINT_BIT);
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
File PCB/MZ-2000_VOCALUINO4CMU/sketch/Vocaluino4CMU_setisyun_CPX/Vocaluino4CMU_setisyun_CPX.ino (part):

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const char ju[] PROGMEM =  "juuuuuuuuuuuuuuuuuuuuuuuuuuuu";
const char je[] PROGMEM =  "jeeeeeeeeeeeeeeeeeeeeeeeeeeee";
const char jo[] PROGMEM =  "joooooooooooooooooooooooooooo";
const char cha[] PROGMEM = "chaaaaaaaaaaaaaaaaaaaaaaaaaaa";
const char tya[] PROGMEM = "tyaaaaaaaaaaaaaaaaaaaaaaaaaaa";
const char chu[] PROGMEM = "chuuuuuuuuuuuuuuuuuuuuuuuuuuu";
const char tyu[] PROGMEM = "tyuuuuuuuuuuuuuuuuuuuuuuuuuuu";
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// ============================================================

// ---------- LS259 input ----------
const int PIN_S0   = A0;   // CHA
const int PIN_S1   = A1;   // CHB
const int PIN_S2   = A2;   // CHC
const int PIN_G    = A3;   // CHD = /G
const int PIN_D    = 8;    // GATE = D
const int PIN_ATP_RST = 13; // *ATP_RST

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// ------------------------------------------------------------
// LS259入力変化割り込み（ATmega328P Pin Change Interrupt）
//
// A0～A3 = PC0～PC3 = PCINT8～11
// D8     = PB0     = PCINT0
// D2～D7 はVDなのでISR内ではPINDから直接読む。
// I2Cはここでは絶対に実行しない。
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